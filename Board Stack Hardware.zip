PC 104 rod_v2 v3 (Autodesk Fusion 360 design; units mm, degrees)
base_feature "Base Feature"